# Keil uVision project simulator.uvproj, settings and files
target Симуляция (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: simulator
  c flags: Optim=1
  c define: ARM_MATH_CM4, __FPU_PRESENT=1,SIMUL
  c include: ..\;..\..\Libraries\Board;..\..\Libraries\CMSIS
  group Main Group
    ../: main.c
    ../../Libraries/Board/: mathfunc.c
  group Library
    ../../Libraries/CMSIS/: arm_sin_q15.c startup_ARMCM4.s system_ARMCM4.c
