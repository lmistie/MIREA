# Keil uVision project indication.uvproj, settings and files
target Ввод данных (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: indication
  c flags: Optim=1 uC99=1
  c define: ARM_MATH_CM4, __FPU_PRESENT=1, STM32F40_41xxx
  c include: ..\;..\..\..\Libraries\Board;..\..\..\Libraries\CMSIS;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  group Main Group
    ../: main.c
  group Library
    ../../../Libraries/CMSIS/: startup_ARMCM4.s system_ARMCM4.c
