# Keil uVision project board.uvproj, settings and files
target Отладочная плата (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: board +hex
  AfterMake: Loader.exe
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, VECT_TAB_SRAM, ARM_MATH_CM4, __FPU_PRESENT=1
  c include: ..\;..\..\Libraries\Board;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main Group
    ../: main.c diagr.c
    ../../Libraries/Board/: mathfunc.c
  group Library
    ./: startup_stm32f4xx.s
    ../../Libraries/Board/: system_stm32f4xx.c stm32_p407.c
    ../../Libraries/CMSIS/: arm_sin_q15.c
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group LCD
    ../../Libraries/Board/: lcd.c drv_glcd.c glcd_ll.c fonts.c
